## ESP-HMI/hello_world/sdkconfig.defaults
```kconfig
CONFIG_IDF_TARGET="esp32s3"
CONFIG_LV_MEM_SIZE_KILOBYTES=64
CONFIG_LV_ASSERT_HANDLER_INCLUDE="assert.h"
```
